# Keil uVision project 34_fsmc_stm32f103_register.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: led_register +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=5 wLevel=2
  c include: .\Start;.\User;.\Hardware\LED;.\Hardware\KEY;.\Hardware\USART;.\Hardware\DMA;.\Hardware\ADC;.\Hardware\FSMC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Start
    ./Start/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group User
    ./User/: main.c delay.c
  group Hardware/LED
    ./Hardware/LED/: led.c
  group Hardware/KEY
    ./Hardware/KEY/: key.c
  group Hardware/USART
    ./Hardware/USART/: usart.c
  group Hardware/DMA
    ./Hardware/DMA/: dma.c
  group Hardware/ADC
    ./Hardware/ADC/: adc.c
  group Hardware/FSMC
    ./Hardware/FSMC/: fsmc.c
