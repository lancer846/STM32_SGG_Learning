# Keil uVision project GD32F407.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.2.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F407 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,HSE_VALUE=8000000
  c include: .\Start;.\User;.\Library\USART;.\Library\I2C;.\Hardware\LED;.\Hardware\KEY;.\Hardware\OLED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c
    ./User/: delay.c
  group Start
    ./Start/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group Lib/USART
    ./Library/USART/: usart.c
  group Lib/I2C
    ./Library/I2C/: i2c.c
  group Hardware/LED
    ./Hardware/LED/: led.c
  group Hardware/KEY
    ./Hardware/KEY/: key.c
  group Hardware/OLED
    ./Hardware/OLED/: oled.c
